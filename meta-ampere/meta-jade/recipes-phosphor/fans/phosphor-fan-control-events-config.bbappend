FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/${MACHINE}:"
