FILESEXTRAPATHS_append_mtjade := "${THISDIR}/${PN}:"

SRC_URI = "git://github.com/ampere-openbmc/ssifbridge.git;protocol=https;branch=ampere"
SRCREV= "072ac3ef7a96d0d040cfa2a1112bbea79cc635f0"
