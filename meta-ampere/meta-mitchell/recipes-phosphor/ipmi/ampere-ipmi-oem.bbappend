TARGET_CPPFLAGS += " -DMAC_ADDRESS_FRU_BUS=14 -DMAC_ADDRESS_FRU_ADDR=80"
